# Keil uVision project stm32f0-contiki.uvproj, settings and files
target stm32f0 (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: stm32f0-contiki
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: ..\app;..\contiki;..\contiki\core;..\contiki\portable;..\cpu;..\cpu\cmsis_inc;..\cpu\inc;..\dev;..\lib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group app
    ../app/: main.c charge.c communication.c channel.c
  group contiki
    ../contiki/core/sys/: autostart.c etimer.c process.c timer.c
  group portable
    ../contiki/portable/: clock.c contiki-default-conf.h contiki-conf.h
  group cpu
    ../cpu/: cpu.c core_cm3.c stm32f0xx_it.c system_stm32f0xx.c startup_stm32f030x8.s
    ../cpu/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_usart.c
  group dev
    ../dev/: dev.c dev_config.c iic.c uart.c 74hc595.c ir.c switch.c flash.c motor.c driver_config.c key.c
  group lib
    ../lib/: lib.c cbuffer.c
