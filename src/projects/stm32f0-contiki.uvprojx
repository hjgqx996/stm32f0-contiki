# Keil uVision project stm32f0-contiki.uvprojx, settings and files
target stm32f0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: stm32f0-contiki +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: ..\app;..\system;..\contiki;..\contiki\core;..\contiki\portable;..\cpu;..\cpu\cmsis_inc;..\cpu\inc;..\dev;..\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group app
    ../app/: main.c thread_system.c thread_insert.c thread_comm.c thread_channel.c config.c
  group system
    ../system/: channel.c queue.c packet.c system.c
  group contiki
    ../contiki/core/sys/: autostart.c etimer.c process.c timer.c
  group portable
    ../contiki/portable/: clock.c contiki-default-conf.h contiki-conf.h
  group dev
    ../dev/: driver_config.c dev.c gpio.c iic.c uart.c ir.c 74hc595.c flash.c timer.c key.c
  group cpu
    ../cpu/: cpu.c core_cm3.c stm32f0xx_it.c system_stm32f0xx.c startup_stm32f030x8.s
    ../cpu/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_usart.c stm32f0xx_tim.c stm32f0xx_exti.c stm32f0xx_syscfg.c
  group lib
    ../lib/: lib.c cbuffer.c
